# Repository vd-rd/sbc_allwinner_a13

File README.md:

# Allwinner A13 Board

## Description

Board overview (draft):
[TBD]

### Features

| Characteristic | Description |
| --- | --- |
| Dimensions | 80mm x 40mm |
| Processor | Allwinner A13 (ARM Cortex-A8 @ 1Ghz) |
| Oscillators |  24MHz main clock |
| RAM | DDR3 512MB max (8Gbit module) |
| Storage | microSD |
| USB | 1 microUSB OTG |
| Ethernet | N/A |
| WiFi/BT | RTL8188CUS module |
| LCD | Parallel interface 18bit |
| Expansions | 1xUART, 1xI2C, 1xSPI, 4xGPIO, Microphone, EarphoneOut |
| Supply | Power path between USB/ACIN/Battery, 5V max |

### Expansions
 The board can be combined with several predefined capes that add functionality.
 * [LCD cape](https://github.com/vd-rd/hw_cape_lcd) can be used to add a 3inch LCD/Touch with 800x480px resolution.
 * [GPS cape](https://github.com/vd-rd/hw_cape_gps) adds GPS/GNSS/GLONAS capabilities
 * [GSM cape](https://github.com/vd-rd/hw_cape_gsm) adds GPRS connectivity. 

### Power considerations

A13 features a few power rails:
* VDD-CPU - TBD - from AXP209
* VDD-INT - 1.2V - from DCDC
* VDD-GPIO - 3V3 - from AXP209
* VDD-DRAM - 1V5 - from DCDC
* AVCC - 3V - from AXP209

The datasheet states that AVCC and VDD-DRAM must be present at all times (even standby).
VDD-INT and VDD-CPU can't be tied together because VDD-CPU is DVS enabled.

### Memory considerations

A13 DRAM controller doesn't provide DDR-CS. On the memory side the pin is tied to GND.
Memory tuning should be performed as [described here](https://linux-sunxi.org/A10_DRAM_Controller_Calibration)

### Building and flashing

Build U-Boot and Linux kernel + rootFS - TBD

Flash to SDCard - TBD

### Resources

You can find all necesary information to build or evaluate the module here:
   - [Fabrication files](https://github.com/vd-rd/sbc_alw_a13/releases)

Inspiration for this has been drawn from:
* Olimex boards 
* Sunxi community

## EAGLE design module.brd

Parts:
CON1: microusb; 10118194
D8: ESD9B5.0ST5G; SOD1006X40
L4, L5: FER-0603; FER0603
LED1: OSTB1204C1E; 321015RGB
R20, R21, R22: 180; R0402
R24: 47k; R0402
SV1: MA18-2
SV2: MA05-2
SV4: MA05-1
U1: A13; QFP40P2200X2200X160-177T700
U3: USBLC6-2P6; SOTFL50P160X60-6
U$1, U$2, U$3: FIDUCIAL; FIDUCIAL_1MM

Connections:
+3V3: LED1.2, R24.2; also elsewhere on the board
CAN_RX: SV1.30
CAN_TX: SV1.29
CAPE_EN1: SV1.13
CAPE_EN2: SV1.14
GND: CON1.5 (GND), D8.2 (C), L5.1, SV1.1, SV4.1; also elsewhere on the board
GPIO0: SV1.19; also elsewhere on the board
GPIO1: SV1.20; also elsewhere on the board
GPIO2: SV1.21; also elsewhere on the board
GPIO3: SV1.22; also elsewhere on the board
GPIO31: SV1.31
GPIO32: SV1.32
GPIO33: SV1.33
GPIO34: SV1.34
GPIO35: SV1.35
GPIO36: SV1.36
I2C_SCL: SV1.17
I2C_SDA: SV1.18
unnamed: CON1.1 (VCC), L4.1
unnamed: LED1.1, R20.2
unnamed: LED1.4, R21.2
unnamed: LED1.3, R22.2
unnamed: CON1.SH1 (GND), CON1.SH2 (GND), CON1.SH3 (GND), CON1.SH4 (GND), CON1.SH5 (GND), CON1.SH6 (GND), CON1.SH7 (GND), CON1.SH8 (GND), L5.2
NRST: SV1.7
SPI_CLK: SV1.25
SPI_MISO: SV1.28
SPI_MOSI: SV1.27
SPI_NSS: SV1.26
UART_RXD0: SV1.12
UART_RXD1: SV1.16
UART_RXD2: SV1.24
UART_TXD0: SV1.11
UART_TXD1: SV1.15
UART_TXD2: SV1.23
UDM0: U1.93 (UDM0)
UDM1: U1.95 (UDM1)
UDP0: U1.94 (UDP0)
UDP1: U1.96 (UDP1)
USBC_DM: CON1.2 (DM)
USBC_DP: CON1.3 (DP)
USBC_ID: CON1.4 (ID), D8.1 (A), R24.1
USB_H1_DM: SV4.2
USB_H1_DP: SV4.3
USB_H2_DM: SV4.4
USB_H2_DP: SV4.5
USB_VCC: L4.2
VBAT: SV1.4
VEXT: SV1.2
VSYS: SV1.3

Parts:
C6, C7: 15pF; C0402
Q1: 24MHz; 3215
R15: 47k; R0402
U1: A13; QFP40P2200X2200X160-177T700

Connections:
!RESET: U1.159 (!RESET); also elsewhere on the board
GND: C6.2, C7.2; also elsewhere on the board
HSE_IN: C6.1, Q1.1, U1.92 (X24MIN)
HSE_OUT: C7.1, Q1.3 (2), U1.91 (X24MOUT)
unnamed: R15.2, U1.158 (!NMI)
SDC_CLK: U1.110 (PF2); also elsewhere on the board
SDC_CMD: U1.111 (PF3); also elsewhere on the board
SDC_D0: U1.108 (PF1); also elsewhere on the board
SDC_D1: U1.107 (PF0); also elsewhere on the board
SDC_D2: U1.113 (PF5); also elsewhere on the board
SDC_D3: U1.112 (PF4); also elsewhere on the board
SDC_DET: U1.155 (PG0); also elsewhere on the board
UART1_RX: U1.151 (PG4)
UART1_TX: U1.152 (PG3)

Parts:
C1, C2, C3, C4, C5: 100nF; C0402
IC1, IC2: IS43TR82560DL; FBGA78
R1: 240; R0402
R2, R3, R4, R5, R6, R7, R8, R9: 22; R0402
R10, R11, R12, R13: 2k; R0402
RN1, RN2, RN3, RN4, RN5, RN6, RN7, RN8: 22; 4D02
U1: A13; QFP40P2200X2200X160-177T700
U$4, U$5: 22; 4D02

Connections:
!CAS: IC1.G3 (!CAS), IC2.G3 (!CAS)
!CK: IC1.G7 (!CK), IC2.G7 (!CK), R8.1
!CS: IC1.H2 (!CS), IC2.H2 (!CS)
!DQS: IC1.D3 (!DQS), IC2.D3 (!DQS)
!RAS: IC1.F3 (!RAS), IC2.F3 (!RAS)
!RESET: IC1.N2 (!RESET), IC2.N2 (!RESET); also elsewhere on the board
!TDQS: IC1.A7 (!TDQS), IC2.A7 (!TDQS)
!WE: IC1.H3 (!WE), IC2.H3 (!WE)
A0: IC1.K3 (A0), IC2.K3 (A0), RN6.8 (2)
A1: IC1.L7 (A1), IC2.L7 (A1), RN4.6 (2)
A2: IC1.L3 (A2), IC2.L3 (A2), RN7.6 (2)
A3: IC1.K2 (A3), IC2.K2 (A3), RN7.5 (2)
A4: IC1.L8 (A4), IC2.L8 (A4), RN4.5 (2)
A5: IC1.L2 (A5), IC2.L2 (A5), RN7.7 (2)
A6: IC1.M8 (A6), IC2.M8 (A6), RN4.7 (2)
A7: IC1.M2 (A7), IC2.M2 (A7), RN8.7 (2)
A8: IC1.N8 (A8), IC2.N8 (A8), RN4.8 (2)
A9: IC1.M3 (A9), IC2.M3 (A9), RN8.5 (2)
A10: IC1.H7 (A10), IC2.H7 (A10), RN3.6 (2)
A11: IC1.M7 (A11), IC2.M7 (A11), RN5.5 (2)
A12: IC1.K7 (A12), IC2.K7 (A12), RN3.8 (2)
A13: IC1.N3 (A13), IC2.N3 (A13), RN7.8 (2)
A14: IC1.N7 (A14), IC2.N7 (A14), RN5.6 (2)
A15: IC1.J7 (A15), IC2.J7 (A15)
BA0: IC1.J2 (BA0), IC2.J2 (BA0), RN6.7 (2)
BA1: IC1.K8 (BA1), IC2.K8 (BA1), RN3.7 (2)
BA2: IC1.J3 (BA2), IC2.J3 (BA2), RN6.6 (2)
CK: IC1.F7 (CK), IC2.F7 (CK), R7.1
CKE: IC1.G9 (CKE), IC2.G9 (CKE), RN3.5 (2)
DQL0: IC1.B3 (DQL0), U$4.8 (2)
DQL1: IC1.C7 (DQL1), RN2.5 (2)
DQL2: IC1.C2 (DQL2), U$4.7 (2)
DQL3: IC1.C8 (DQL3), RN2.6 (2)
DQL4: IC1.E3 (DQL4), U$4.5 (2)
DQL5: IC1.E8 (DQL5), RN2.8 (2)
DQL6: IC1.D2 (DQL6), U$4.6 (2)
DQL7: IC1.E7 (DQL7), RN2.7 (2)
DQM0: IC2.B3 (DQL0), RN1.6 (2)
DQM1: IC2.C7 (DQL1), U$5.6 (2)
DQM2: IC2.C2 (DQL2), RN1.8 (2)
DQM3: IC2.C8 (DQL3), U$5.5 (2)
DQM4: IC2.E3 (DQL4), RN1.5 (2)
DQM5: IC2.E8 (DQL5), U$5.7 (2)
DQM6: IC2.D2 (DQL6), RN1.7 (2)
DQM7: IC2.E7 (DQL7), U$5.8 (2)
DQS: IC1.C3 (DQS), IC2.C3 (DQS)
GND: C1.2, C3.2, C5.2, R1.2, R11.1, R13.1; also elsewhere on the board
unnamed: U1.22 (DATA0), U$4.1
unnamed: RN2.4 (1), U1.40 (DATA1)
unnamed: U1.21 (DATA2), U$4.2 (1)
unnamed: RN2.3 (1), U1.41 (DATA3)
unnamed: U1.19 (DATA4), U$4.4 (1)
unnamed: RN2.1, U1.44 (DATA5)
unnamed: U1.20 (DATA6), U$4.3 (1)
unnamed: RN2.2 (1), U1.42 (DATA7)
unnamed: RN1.3 (1), U1.37 (DATA8)
unnamed: U1.25 (DATA9), U$5.3 (1)
unnamed: RN1.1, U1.39 (DATA10)
unnamed: U1.24 (DATA11), U$5.4 (1)
unnamed: RN1.4 (1), U1.36 (DATA12)
unnamed: U1.26 (DATA13), U$5.2 (1)
unnamed: RN1.2 (1), U1.38 (DATA14)
unnamed: U1.27 (DATA15), U$5.1
unnamed: RN6.1, U1.64 (ADDR0)
unnamed: RN4.3 (1), U1.52 (ADDR1)
unnamed: RN7.3 (1), U1.66 (ADDR2)
unnamed: RN7.4 (1), U1.65 (ADDR3)
unnamed: RN4.4 (1), U1.51 (ADDR4)
unnamed: RN7.2 (1), U1.67 (ADDR5)
unnamed: RN4.2 (1), U1.54 (ADDR6)
unnamed: RN8.2 (1), U1.71 (ADDR7)
unnamed: RN4.1, U1.55 (ADDR8)
unnamed: RN8.4 (1), U1.69 (ADDR9)
unnamed: RN3.3 (1), U1.48 (ADDR10)
unnamed: RN5.4 (1), U1.56 (ADDR11)
unnamed: RN3.1, U1.50 (ADDR12)
unnamed: RN7.1, U1.68 (ADDR13)
unnamed: RN5.3 (1), U1.57 (ADDR14)
unnamed: RN6.2 (1), U1.63 (BA0)
unnamed: RN3.2 (1), U1.49 (BA1)
unnamed: RN6.3 (1), U1.61 (BA2)
unnamed: R7.2, U1.45 (CK)
unnamed: R8.2, U1.46 (!CK)
unnamed: RN3.4 (1), U1.47 (CKE)
unnamed: RN5.2 (1), U1.58 (RAS)
unnamed: RN5.1, U1.59 (CAS)
unnamed: RN6.4 (1), U1.60 (WE)
unnamed: RN8.3 (1), U1.70 (RST)
unnamed: R2.2, U1.29 (DM0)
unnamed: R3.2, U1.28 (DM1)
unnamed: R5.1, U1.31 (DQS0)
unnamed: R6.1, U1.33 (DQS1)
unnamed: R4.1, U1.32 (!DQS0)
unnamed: R9.1, U1.34 (!DQS1)
unnamed: RN8.1, U1.72 (ODT)
unnamed: R1.1, U1.17 (DZQ)
NC: IC1.A3 (NC), IC1.F1 (NC), IC1.F9 (NC), IC1.H1 (NC), IC1.H9 (NC), IC2.A3 (NC), IC2.F1 (NC), IC2.F9 (NC), IC2.H1 (NC), IC2.H9 (NC)
ODT: IC1.G1 (ODT), IC2.G1 (ODT)
SVREF: C1.1, C2.2, C3.1, R10.1, R11.2, U1.18 (SVREF)
TDQS: IC1.B7 (TDQS), IC2.B7 (TDQS)
VCC-DRAM: C2.1, C4.1, R10.2, R12.2
VDD: IC1.A2 (VDD), IC1.A9 (VDD), IC1.D7 (VDD), IC1.G2 (VDD), IC1.G8 (VDD), IC1.K1 (VDD), IC1.K9 (VDD), IC1.M1 (VDD), IC1.M9 (VDD), IC2.A2 (VDD), IC2.A9 (VDD), IC2.D7 (VDD), IC2.G2 (VDD), IC2.G8 (VDD), IC2.K1 (VDD), IC2.K9 (VDD), IC2.M1 (VDD), IC2.M9 (VDD)
VDDQ: IC1.B9 (VDDQ), IC1.C1 (VDDQ), IC1.E2 (VDDQ), IC1.E9 (VDDQ), IC2.B9 (VDDQ), IC2.C1 (VDDQ), IC2.E2 (VDDQ), IC2.E9 (VDDQ)
VREFCA: C4.2, C5.1, R12.1, R13.2
VSS: IC1.A1 (VSS), IC1.A8 (VSS), IC1.B1 (VSS), IC1.D8 (VSS), IC1.F2 (VSS), IC1.F8 (VSS), IC1.J1 (VSS), IC1.J9 (VSS), IC1.L1 (VSS), IC1.L9 (VSS), IC1.N1 (VSS), IC1.N9 (VSS), IC2.A1 (VSS), IC2.A8 (VSS), IC2.B1 (VSS), IC2.D8 (VSS), IC2.F2 (VSS), IC2.F8 (VSS), IC2.J1 (VSS), IC2.J9 (VSS), IC2.L1 (VSS), IC2.L9 (VSS), IC2.N1 (VSS), IC2.N9 (VSS)
VSSQ: IC1.B2 (VSSQ), IC1.B8 (VSSQ), IC1.C9 (VSSQ), IC1.D1 (VSSQ), IC1.D9 (VSSQ), IC2.B2 (VSSQ), IC2.B8 (VSSQ), IC2.C9 (VSSQ), IC2.D1 (VSSQ), IC2.D9 (VSSQ)

Parts:
C8: 100nF; C0402K
C45, C46, C47: C-EUC0402; C0402
CON2: 112J-TXAR; 112J
D1, D2, D3, D4, D5, D6, D7: ESD9B5.0ST5G; SOD1006X40
J1: U.FL-R-SMT(01); HRS_U.FL-R-SMT(01)
R14: 33; R0402
R16, R17: 47k; R0402
R18: R-EU_R0402; R0402
U4: RTL8723BS; QFN90P1200X1200X100-44
U$6: 47k; 4D02

Connections:
+3V3: C8.1, CON2.P$4 (VDD), D4.2 (C), R16.1, R17.1, U$6.5 (2), U$6.6 (2), U$6.7 (2), U$6.8 (2); also elsewhere on the board
GND: C8.2, C46.1, C47.1, CON2.GND1 (GND), CON2.GND2 (GND), CON2.GND3 (GND), CON2.GND4 (GND), CON2.P$6 (VSS), D1.1 (A), D2.1 (A), D3.1 (A), D4.1 (A), D5.1 (A), D6.1 (A), D7.1 (A), J1.1 (GND), J1.2 (GND), U4.1 (GND), U4.3 (GND), U4.20 (GND), U4.31 (GND), U4.33 (GND), U4.36 (GND); also elsewhere on the board
unnamed: C45.2, U4.2 (WL_BT_ANT)
unnamed: C45.1, C46.2, R18.2
unnamed: C47.2, J1.3 (SIG), R18.1
SDC1_CLK: U4.17 (SDIO_CLK)
SDC1_CMD: U4.16 (SDIO_CMD)
SDC1_D0: U4.18 (SDIO_D0)
SDC1_D1: U4.19 (SDIO_D1)
SDC1_D2: U4.14 (SDIO_D2)
SDC1_D3: U4.15 (SDIO_D3)
SDC_CLK: R14.1; also elsewhere on the board
SDC_CLK_R: CON2.P$5 (CLK), D5.2 (C), R14.2
SDC_CMD: CON2.P$3 (CMD), D3.2 (C), U$6.3 (1); also elsewhere on the board
SDC_D0: CON2.P$7 (DAT0), D6.2 (C), U$6.4 (1); also elsewhere on the board
SDC_D1: CON2.P$8 (DAT1), D7.2 (C), R16.2; also elsewhere on the board
SDC_D2: CON2.P$1 (DAT2), D1.2 (C), U$6.1; also elsewhere on the board
SDC_D3: CON2.P$2 (CD/DAT3), D2.2 (C), U$6.2 (1); also elsewhere on the board
SDC_DET: CON2.P$13 (CD), R17.2; also elsewhere on the board
WL_HOST_WAKE: U4.13 (WL_HOST_WAKE)

Parts:
IC3: MCP1640; SOT95P280X110-6
L1, L2, L3, L6: DJNR3015; L3230M
U2: AXP209; QFN40P600X600X80-49T405

Connections:
!OE: U2.4 (!OE)
!VBUSEN: U2.6 (!VBUSEN)
AGND: U2.22 (AGND)
APS: U2.21 (APS)
BACKUP: U2.30 (BACKUP)
BATSENSE: U2.42 (BATSENSE)
BIAS: U2.23 (BIAS)
CHGLED: U2.36 (CHGLED)
CHSENSE: U2.43 (CHSENSE)
EP: U2.49 (EP), U2.P$1 (EP), U2.P$2 (EP), U2.P$3 (EP), U2.P$4 (EP), U2.P$5 (EP), U2.P$6 (EP), U2.P$7 (EP), U2.P$8 (EP), U2.P$9 (EP)
EXTEN: U2.20 (EXTEN)
GPIO0: U2.19 (GPIO0); also elsewhere on the board
GPIO1: U2.18 (GPIO1); also elsewhere on the board
GPIO2: U2.5 (GPIO2); also elsewhere on the board
GPIO3: U2.3 (GPIO3); also elsewhere on the board
IRQ: U2.48 (IRQ)
LDO1: U2.28 (LDO1)
LDO1SET: U2.27 (LDO1SET)
LDO2: U2.12 (LDO2)
LDO3: U2.41 (LDO3)
LDO3IN: U2.40 (LDO3IN)
LDO4: U2.11 (LDO4)
LDO24IN: U2.13 (LDO24IN)
unnamed: U2.38 (BAT), U2.39 (BAT)
unnamed: U2.34 (IPSOUT), U2.35 (IPSOUT)
unnamed: IC3.1 (SW), L6.2
unnamed: IC3.6 (VIN), L6.1
unnamed: L3.1, U2.15 (LX3)
unnamed: L2.1, U2.8 (LX2)
unnamed: L1.1, U2.45 (LX1)
unnamed: U2.32 (ACIN), U2.33 (ACIN)
POWOK: U2.25 (POWOK)
PWRON: U2.47 (PWRON)
SCK: U2.2 (SCK)
SDA: U2.1 (SDA)
TS@37: U2.37 (TS)
VBUS@31: U2.31 (VBUS)
VINT: U2.26 (VINT)
VREF: U2.24 (VREF)

Board: 4 copper layers, 76 parts (1 on the bottom side), 140 nets, no tracks yet.

## Commit log (part)

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2019-04-30 board: define board shape and connectors
2019-04-30 board: add processor and ram
2019-04-30 board: add ddr3 termination resistors
2019-04-30 schematic: defined ddr3 connections
2019-04-30 schematic: added more sdram nets
2019-04-30 schematic: defined functions for peripherals
2019-04-30 board: add power components
2019-05-01 board: added esd protection
2019-05-02 board: added wifi/bt combo module
2021-09-22 project cleanup
2021-09-22 switch to kicad
2021-09-22 updated layout
2021-09-24 improve floorplan
2021-09-27 defined floorplan for board
2021-10-16 added pmic
2021-10-17 new layout for dram chip
2021-10-19 optimize dram placement
2021-10-19 swapped wifi module
2021-10-23 added lcd connector and bl driver
2021-10-25 added 3d models
2021-11-15 defined floorplan
2021-11-25 more dram routing
2021-12-05 small changes to ram layout
2021-12-12 more ddr routing
2021-12-13 pmic optimizations
2021-12-17 pmic routing
2021-12-24 more signal routing
2021-12-27 testing new layout
2021-12-27 reposition components on tryout board
2021-12-30 reaching rc0.1
2021-12-31 add dcdc for 1.2v int rail
2022-01-02 added audio breakout
2022-01-02 add board preview
2022-01-03 small changes
2022-01-11 routed sdio0 bus
2022-01-14 added missing values for components
2022-01-16 add layer identification labels
2022-01-17 preparing for release
2022-01-18 added all lcd connector signals
2022-01-18 power rails completed
2022-01-18 board fully routed
2022-01-19 exported gerbers
2022-01-29 added testpoints for RSB
2022-01-29 prepare for v1.1.0
2022-01-30 add new lcd connector
2022-02-02 route new lcd connector
2022-02-02 swapped rtc for mcp794x
2022-02-11 small rtc fixes
2022-02-16 add global fiducials
2022-02-16 add silkscreen info for big footprints
2022-02-21 small fixes
2022-02-21 add a testpoint
2022-02-22 swap inductors for smaller footprints
2022-03-01 fix pull-up values
2022-03-09 fix testpoint position
2022-03-24 add ldo3 cap
2022-03-24 new board features
    axp209 adc pins
    chg led
2022-03-24 finish aux pmics
2022-03-28 prepare new board revision
2022-03-30 prep for fab
2022-04-05 added new uart port
2022-04-07 relax spacing between signals
2022-04-30 add board info
2022-06-30 swap rtc for onboard spi
2022-07-01 update board preview
2022-07-07 fix audio connector
2022-07-10 clean board silkscreen
2022-07-10 add alternative parts
2023-12-25 chore: update to kicad7 format
2024-03-31 bump to kicad v8
2024-08-16 latest fixes for fab
2024-08-16 updated silk and description
2024-10-28 [WIP] Rework power tree
2025-01-10 rework component placement
2025-01-10 Add MkDocs Material pages
2025-01-10 Add basic mkdocs config
2025-01-10 organize project structure
2025-01-10 add first docs
2025-01-10 fix typo
2025-01-10 enable plugins
2025-07-19 wip rework
2026-01-04 prepare for rev2
2026-01-04 small cosmetic fixes
2026-01-05 axp209 layout optimisations
2026-01-26 updated cpu connections
2026-02-03 more routing
2026-04-26 Refactor code structure for improved readability and maintainability
2026-04-29 more routing for v2
2026-04-29 finished routing rev2
2026-05-03 finished routing v2
2026-05-27 update board renders for rev2
2026-06-09 drc and cosmetics for rev2
2026-06-29 test release workflow
2026-06-29 test release workflow (#10)
