# Repository vd-rd/sbc_allwinner_a13

File README.md:

# Allwinner A13 Board

## Description

Board overview (draft):
[TBD]

### Features

| Characteristic | Description |
| --- | --- |
| Dimensions | 80mm x 40mm |
| Processor | Allwinner A13 (ARM Cortex-A8 @ 1Ghz) |
| Oscillators |  24MHz main clock |
| RAM | DDR3 512MB max (8Gbit module) |
| Storage | microSD |
| USB | 1 microUSB OTG |
| Ethernet | N/A |
| WiFi/BT | RTL8188CUS module |
| LCD | Parallel interface 18bit |
| Expansions | 1xUART, 1xI2C, 1xSPI, 4xGPIO, Microphone, EarphoneOut |
| Supply | Power path between USB/ACIN/Battery, 5V max |

### Expansions
 The board can be combined with several predefined capes that add functionality.
 * [LCD cape](https://github.com/vd-rd/hw_cape_lcd) can be used to add a 3inch LCD/Touch with 800x480px resolution.
 * [GPS cape](https://github.com/vd-rd/hw_cape_gps) adds GPS/GNSS/GLONAS capabilities
 * [GSM cape](https://github.com/vd-rd/hw_cape_gsm) adds GPRS connectivity. 

### Power considerations

A13 features a few power rails:
* VDD-CPU - TBD - from AXP209
* VDD-INT - 1.2V - from DCDC
* VDD-GPIO - 3V3 - from AXP209
* VDD-DRAM - 1V5 - from DCDC
* AVCC - 3V - from AXP209

The datasheet states that AVCC and VDD-DRAM must be present at all times (even standby).
VDD-INT and VDD-CPU can't be tied together because VDD-CPU is DVS enabled.

### Memory considerations

A13 DRAM controller doesn't provide DDR-CS. On the memory side the pin is tied to GND.
Memory tuning should be performed as [described here](https://linux-sunxi.org/A10_DRAM_Controller_Calibration)

### Building and flashing

Build U-Boot and Linux kernel + rootFS - TBD

Flash to SDCard - TBD

### Resources

You can find all necesary information to build or evaluate the module here:
   - [Fabrication files](https://github.com/vd-rd/sbc_alw_a13/releases)

Inspiration for this has been drawn from:
* Olimex boards 
* Sunxi community

## KiCad design hardware/module.kicad_pcb

Parts:
AE1: Antenna_Shield; U.FL_Hirose_U.FL-R-SMT-1_Vertical
C912: 10uF; C_0603_1608Metric
C914: 100nF; C_0402_1005Metric
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_2.7mm_M2.5_DIN965
U2: RTL8188CUS

Connections:
+3V3_periph: C912.1, C914.1, U2.4 (+3V3); also elsewhere on the board
GND: AE1.2 (Shield), C912.2, C914.2, U2.1 (GND), U2.5 (GND); also elsewhere on the board
unnamed: AE1.1 (A), U2.6 (ANT)
USB1-D+: U2.2 (USB_DP); also elsewhere on the board
USB1-D-: U2.3 (USB_DM); also elsewhere on the board

Notes on the sheet:
LDO1
LDO5
VddWiFi (+3.3V)
CPU Allwinner A13
DCDC3
SPI
DCDC6
VddOTG (+5V)
WiFI/BT Combo
DCDC4
LDO4
VddCPU (+1.2V)
VddANA (+3.0V)
VddCORE (+1.2V)
SDIO
USB
DCDC1
LDO3
DCDC5
ACIN
LDO2
LiIon Batt
VddRTC (+3.3V)
USB-Power
AXP209
DCDC2
MicroSD Connector
NOR Flash
VddIO (+3.3V)
PowerPath
VddDDR (+1.5V)

Parts:
C601, C701, C702, C807, C810, C813, C817, C831, C833, C835, C839, C840, C843, C901, C902, C910, C911: 10uF; C_0603_1608Metric
C811, C812, C821, C844, C860: 4.7uF; C_0603_1608Metric
C824, C826, C828: 1uF; C_0402_1005Metric
C8211: 100nF; C_0402_1005Metric
D3: LED_Small; LED_0603_1608Metric
L1, L910: 1uH; L_Wuerth_MAPI-2510
L2: 4.7uH; L_Wuerth_MAPI-2510
L3, L4, L5: 4.7uH; L_Wuerth_MAPI-2512
R18: 30m; R_0603_1608Metric
R21, R804: 2.2k; R_0402_1005Metric
R601: 976k; R_0402_1005Metric
R602: 562k; R_0402_1005Metric
R701: 100K; R_0402_1005Metric
R801, R802: 1.8k; R_0402_1005Metric
R823: 200K; R_0402_1005Metric
R825, R848: 47k; R_0402_1005Metric
R901, R911: 200k; R_0402_1005Metric
R902: 133k; R_0402_1005Metric
R910: R_0402_1005Metric
TH1: Thermistor_NTC; R_0603_1608Metric
TP2, TP3, TP5, TP14, TP15, TP16, TP17: TestPoint; TestPoint_Pad_D1.0mm
U600: MCP1640CH; SOT-23-6
U700: AP22811; SOT-23-5
U800: AXP209; QFN-48-1EP_6x6mm_P0.4mm_EP4.2x4.2mm_ThermalVias
U900, U910: AP61100; SOT-563

Connections:
+1V2_CPU: C810.1, L4.2, TP15.1 (1_1), U800.10 (DCDC2); also elsewhere on the board
+1V2_INT: C817.1, L5.2, TP2.1 (1_1), U800.17 (DCDC3); also elsewhere on the board
+1V5: C902.1, L1.2, R901.1, TP17.1 (1_1), U900.6 (OUT); also elsewhere on the board
+3V0: C812.1, TP3.1 (1_1), U800.12 (LDO2), U900.5 (EN); also elsewhere on the board
+3V3: C911.1, L910.2, R801.1, R802.1, R825.1, R848.1, R910.1, TP5.1 (1_1), U910.6 (OUT); also elsewhere on the board
+3V3_RTC: C828.1, U800.28 (LDO1)
+3V3_periph: C811.1, U800.11 (LDO4); also elsewhere on the board
+5V_USB: C702.1, C831.1, U700.1 (OUT), U800.31 (VBUS); also elsewhere on the board
+Vlcd: C860.1, U800.41 (LDO3); also elsewhere on the board
/PMIC & power rails/lx1: C843.1, L3.2, R18.1, U800.43 (CHSENSE)
/PMIC & power rails/lx2: L4.1, U800.8 (LX2)
/PMIC & power rails/lx3: L5.1, U800.15 (LX3)
/PMIC & power rails/pmu_en: R804.2, U800.4 (~OE)
/PMIC & power rails/usb_vbus: C701.1, R601.1, U600.5 (VOUT), U700.5 (IN)
/PMIC & power rails/vint: C826.1, U800.26 (VINT), U800.27 (LDO1SET)
ACIN: C833.1, U800.32 (ACIN), U800.33 (ACIN); also elsewhere on the board
BAT_NTC: TH1.1, U800.37 (TS); also elsewhere on the board
EXTEN: U800.20 (EXTEN), U910.5 (EN)
GND: C601.2, C701.2, C702.2, C807.2, C810.2, C811.2, C812.2, C813.2, C817.2, C821.2, C824.2, C826.2, C828.2, C831.2, C833.2, C835.2, C839.2, C840.2, C843.2, C844.2, C860.2, C901.2, C902.2, C910.2, C911.2, C8211.2, R602.2, R701.2, R804.1, R823.2, R902.2, R911.2, TH1.2, TP14.1 (1_1), U600.2 (GND), U700.2 (GND), U800.9 (PGND2), U800.16 (PGND3), U800.22 (AGND), U800.46 (PGND1), U800.49 (EP), U900.2 (GND), U910.2 (GND); also elsewhere on the board
GPIOA1: U800.19 (GPIO0); also elsewhere on the board
GPIOA2: U800.18 (GPIO1); also elsewhere on the board
GPIOA3: U800.5 (GPIO2); also elsewhere on the board
GPIOA4: U800.3 (GPIO3); also elsewhere on the board
IPS: C601.1, C807.1, C813.1, C821.1, C835.1, C840.1, C844.1, C901.1, C910.1, C8211.1, D3.2 (A), L2.2, TP16.1 (1_1), U600.6 (VIN), U800.7 (VIN2), U800.13 (LDO24IN), U800.14 (VIN3), U800.21 (APS), U800.34 (IPSOUT), U800.35 (IPSOUT), U800.40 (LDO3IN), U800.44 (VIN1), U900.3 (VIN), U910.3 (VIN)
NMI: R848.2, U800.48 (IRQ); also elsewhere on the board
unnamed: D3.1 (K), R21.1
unnamed: L2.1, U600.1 (SW)
unnamed: R601.2, R602.1, U600.4 (VFB)
unnamed: R823.1, U800.23 (BIAS)
unnamed: R21.2, U800.36 (CHGLED)
unnamed: L3.1, U800.45 (LX1)
unnamed: C824.1, U800.24 (VREF)
unnamed: R901.2, R902.1, U900.1 (FB)
unnamed: L1.1, U900.4 (SW)
unnamed: R910.2, R911.1, U910.1 (FB)
unnamed: L910.1, U910.4 (SW)
PMU-VBUSEN: R701.1, U600.3 (EN), U700.4 (EN), U800.6 (~VBUSEN); also elsewhere on the board
PWRON: U800.47 (PWRON); also elsewhere on the board
RSB-SCK: R802.2, U800.2 (SCK); also elsewhere on the board
RSB-SDA: R801.2, U800.1 (SDA); also elsewhere on the board
VBAT: C839.1, R18.2, U800.38 (BAT), U800.39 (BAT), U800.42 (BATSENSE); also elsewhere on the board
~RST: R825.2, U800.25 (POWOK); also elsewhere on the board

Notes on the sheet:
DCDC5
can be substituted with ap61300 or ap62300
can be substituted with DIO6305
DCDC4
can be substituted with AP2161

Parts:
C1, C4, C6, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34: 100nF; C_0402_1005Metric
C2, C9: 10uF; C_0603_1608Metric
C3, C7: 22pF; C_0402_1005Metric
C5: 4.7uF; C_0603_1608Metric
C8: 1uF; C_0402_1005Metric
J200: Conn_02x05_Odd_Even; PinHeader_2x05_P1.27mm_Vertical
R5, R22: 200k; R_0402_1005Metric
R17: 470k; R_0402_1005Metric
R188, R189: 1.8k; R_0402_1005Metric
TP4: TestPoint; TestPoint_Pad_D1.0mm
U4: W25Q128JVS; SOIC-8_5.3x5.3mm_P1.27mm
U100: A13; LQFP-176_20x20mm_P0.4mm
Y1: 24MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V2_CPU: C12.1, C13.1, C17.1, C21.1, C25.1, C29.1, C33.1, C34.1, U100.4 (VDD_CPU), U100.9 (VDD_CPU), U100.11 (VDD_CPU), U100.16 (VDD_CPU), U100.156 (VDD_CPU), U100.164 (VDD_CPU), U100.169 (VDD_CPU), U100.173 (VDD_CPU); also elsewhere on the board
+1V2_INT: C16.1, C20.1, C24.1, C28.1, C32.1, U100.35 (VDD_INT), U100.73 (VDD_INT), U100.98 (VDD_INT), U100.109 (VDD_INT), U100.149 (VDD_INT); also elsewhere on the board
+1V5: C15.1, C19.1, C23.1, C27.1, C31.1, U100.23 (VCC_DRAM), U100.30 (VCC_DRAM), U100.43 (VCC_DRAM), U100.53 (VCC_DRAM), U100.62 (VCC_DRAM); also elsewhere on the board
+3V0: C1.1, U100.81 (AVCC); also elsewhere on the board
+3V3: C11.1, C14.1, C18.1, C22.1, C26.1, C30.1, R188.1, R189.1, U4.3 (IO2), U4.7 (IO3), U4.8 (VCC), U100.5 (IOVCC), U100.97 (UVCC), U100.100 (IOVCC), U100.142 (IOVCC), U100.163 (IOVCC); also elsewhere on the board
+5V_USB: R22.1; also elsewhere on the board
/CPU Signals/hp_bp: C2.1, C4.1, U100.75 (HPBP)
/CPU Signals/hp_vcc: C10.1, U100.76 (V33_HP)
/CPU Signals/hpcom: J200.2, U100.77 (HPCOM)
/CPU Signals/hpoutl: J200.4, U100.74 (HPOUTL)
/CPU Signals/hpoutr: J200.3, U100.78 (HPOUTR)
/CPU Signals/hse_in: C7.1, U100.92 (X24MIN), Y1.3
/CPU Signals/hse_out: C3.1, U100.91 (X24MOUT), Y1.1
/CPU Signals/micin: J200.8, U100.84 (MICIN1)
/CPU Signals/vmic: J200.9, U100.85 (VMIC)
/CPU Signals/vra1: C8.1, U100.83 (VRA1)
/CPU Signals/vra2: C5.1, C6.1, R5.1, U100.82 (VRA2)
/CPU Signals/vrp: C9.1, U100.80 (VRP)
BUTTON: U100.86 (LRADC); also elsewhere on the board
FEL: TP4.1 (1_1), U100.157 (UBOOT)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, J200.1, J200.10, R5.2, R17.2, U4.4 (GND), U100.79 (AGND), U100.177 (GND); also elsewhere on the board
GPIO1: U100.2 (PC4); also elsewhere on the board
GPIO2: U100.1 (PC5); also elsewhere on the board
GPIO3: U100.168 (PC12); also elsewhere on the board
GPIO4: U100.167 (PC13); also elsewhere on the board
I2C-SCL: R188.2, U100.105 (PB15); also elsewhere on the board
I2C-SDA: R189.2, U100.106 (PB16); also elsewhere on the board
LCD-CLK: U100.129 (PD24); also elsewhere on the board
LCD-D2: U100.148 (PD2); also elsewhere on the board
LCD-D3: U100.147 (PD3); also elsewhere on the board
LCD-D4: U100.146 (PD4); also elsewhere on the board
LCD-D5: U100.145 (PD5); also elsewhere on the board
LCD-D6: U100.144 (PD6); also elsewhere on the board
LCD-D7: U100.143 (PD7); also elsewhere on the board
LCD-D10: U100.141 (PD10); also elsewhere on the board
LCD-D11: U100.140 (PD11); also elsewhere on the board
LCD-D12: U100.139 (PD12); also elsewhere on the board
LCD-D13: U100.138 (PD13); also elsewhere on the board
LCD-D14: U100.137 (PD14); also elsewhere on the board
LCD-D15: U100.136 (PD15); also elsewhere on the board
LCD-D18: U100.135 (PD18); also elsewhere on the board
LCD-D19: U100.134 (PD19); also elsewhere on the board
LCD-D20: U100.133 (PD20); also elsewhere on the board
LCD-D21: U100.132 (PD21); also elsewhere on the board
LCD-D22: U100.131 (PD22); also elsewhere on the board
LCD-D23: U100.130 (PD23); also elsewhere on the board
LCD-DE: U100.128 (PD25); also elsewhere on the board
LCD-HSYNC: U100.127 (PD26); also elsewhere on the board
LCD-VSYNC: U100.126 (PD27); also elsewhere on the board
LCD_BL: U100.103 (PB2); also elsewhere on the board
LCD_RESET: U100.155 (PG0); also elsewhere on the board
LED_BLUE: U100.162 (PC19); also elsewhere on the board
LED_GREEN: U100.165 (PC15); also elsewhere on the board
LED_RED: U100.166 (PC14); also elsewhere on the board
NMI: U100.158 (NMI_N); also elsewhere on the board
PMU-VBUSEN: U100.15 (PG12); also elsewhere on the board
RSB-SCK: U100.101 (PB0); also elsewhere on the board
RSB-SDA: U100.102 (PB1); also elsewhere on the board
SDC0-CLK: U100.110 (PF2); also elsewhere on the board
SDC0-CMD: U100.111 (PF3); also elsewhere on the board
SDC0-D0: U100.108 (PF1); also elsewhere on the board
SDC0-D1: U100.107 (PF0); also elsewhere on the board
SDC0-D2: U100.113 (PF5); also elsewhere on the board
SDC0-D3: U100.112 (PF4); also elsewhere on the board
SDC0-DET: U100.104 (PB4); also elsewhere on the board
SDC2-CLK: U100.175 (PC7)
SDC2-CMD: U100.176 (PC6); also elsewhere on the board
SDC2-D0: U100.174 (PC8)
SDC2-D1: U100.172 (PC9)
SDC2-D2: U100.171 (PC10)
SDC2-D3: U100.170 (PC11)
SPI-CLK: U4.6 (CLK), U100.6 (PC2); also elsewhere on the board
SPI-CS: U4.1 (~CS), U100.3 (PC3)
SPI-MISO: U4.2 (DO(IO1)), U100.7 (PC1); also elsewhere on the board
SPI-MOSI: U4.5 (DI(IO0)), U100.8 (PC0); also elsewhere on the board
TOUCH-XL: U100.87 (TPX2); also elsewhere on the board
TOUCH-XR: U100.89 (TPX1); also elsewhere on the board
TOUCH-YD: U100.88 (TPY2); also elsewhere on the board
TOUCH-YU: U100.90 (TPY1); also elsewhere on the board
UART1-RXD: U100.151 (PG4); also elsewhere on the board
UART1-TXD: U100.152 (PG3); also elsewhere on the board
UART2-RX: U100.13 (PG10); also elsewhere on the board
UART2-TX: U100.12 (PG9); also elsewhere on the board
USB0-D+: U100.94 (UDP0); also elsewhere on the board
USB0-D-: U100.93 (UDM0); also elsewhere on the board
USB0_DET: R17.1, R22.2, U100.10 (PB10)
USB0_ID: U100.14 (PG11); also elsewhere on the board
USB1-D+: U100.96 (UDP1); also elsewhere on the board
USB1-D-: U100.95 (UDM1); also elsewhere on the board
~RST: U100.159 (RESET_N); also elsewhere on the board

Parts:
C35: 100nF; C_0603_1608Metric
C36: 1uF; C_0402_1005Metric
C38, C44, C45: 100nF; C_0402_1005Metric
C43: 10uF; C_0603_1608Metric
D2: ESD9B5.0ST5G; D_SOD-923
D4: LED_BAGR; LED_RGB_Optosupply_OSTB0805C1E-A-0.8T
J1: Conn_02x18_Odd_Even; PinHeader_2x18_P2.54mm_Vertical
J100: USB_B_Micro; USB_Micro-B_Amphenol_10103594-0001LF_Horizontal
J101: Micro_SD_Card_Det; MEM20610118800A
J300: Conn_02x22_Odd_Even; PinHeader_2x22_P1.27mm_Vertical
R6, R7, R8: 180; R_0402_1005Metric
R9: 1k; R_0402_1005Metric
R16: 47k; R_0402_1005Metric
R19: 100k; R_0402_1005Metric
R20: 6.8k; R_0402_1005Metric
SW1, SW2: SW_Push; SW_SPST_EVQP7C
U1: USBLC6-2P6; SOT-23-6

Connections:
+3V0: C45.1, R19.1; also elsewhere on the board
+3V3: C35.1, C36.1, D4.2 (A), J1.2, J101.P4 (VDD), J300.43, R16.1; also elsewhere on the board
+5V_USB: J100.1 (VBUS), U1.5 (VBUS); also elsewhere on the board
+Vlcd: C43.1, C44.1, J300.8; also elsewhere on the board
/IO Connectors/usb-d+: J100.3 (D+), U1.3 (I/O2)
/IO Connectors/usb-d-: J100.2 (D-), U1.1 (I/O1)
ACIN: J1.3; also elsewhere on the board
BAT_NTC: J1.6; also elsewhere on the board
BUTTON: R19.2, R20.1; also elsewhere on the board
CAN-RX: J1.30
CAN-TX: J1.29
GND: C35.2, C36.2, C38.2, C43.2, C44.2, C45.2, D2.2 (A2), J1.1, J1.5, J1.14, J1.23, J1.36, J100.5 (GND), J100.6 (Shield), J101.G1 (SHIELD), J101.G2 (SHIELD), J101.P6 (VSS), J300.1, J300.10, J300.11, J300.18, J300.19, J300.26, J300.27, J300.34, J300.35, J300.36, J300.37, J300.44, SW1.1, SW2.1, U1.2 (GND); also elsewhere on the board
GPIO1: J1.13; also elsewhere on the board
GPIO2: J1.20; also elsewhere on the board
GPIO3: J1.19; also elsewhere on the board
GPIO4: J1.24; also elsewhere on the board
GPIOA1: J1.31; also elsewhere on the board
GPIOA2: J1.32; also elsewhere on the board
GPIOA3: J1.33; also elsewhere on the board
GPIOA4: J1.34; also elsewhere on the board
GPIOA5: J1.35
I2C-SCL: J1.17, J300.6; also elsewhere on the board
I2C-SDA: J1.18, J300.7; also elsewhere on the board
LCD-CLK: J300.39; also elsewhere on the board
LCD-D2: J300.33; also elsewhere on the board
LCD-D3: J300.32; also elsewhere on the board
LCD-D4: J300.31; also elsewhere on the board
LCD-D5: J300.30; also elsewhere on the board
LCD-D6: J300.29; also elsewhere on the board
LCD-D7: J300.28; also elsewhere on the board
LCD-D10: J300.25; also elsewhere on the board
LCD-D11: J300.24; also elsewhere on the board
LCD-D12: J300.23; also elsewhere on the board
LCD-D13: J300.22; also elsewhere on the board
LCD-D14: J300.21; also elsewhere on the board
LCD-D15: J300.20; also elsewhere on the board
LCD-D18: J300.17; also elsewhere on the board
LCD-D19: J300.16; also elsewhere on the board
LCD-D20: J300.15; also elsewhere on the board
LCD-D21: J300.14; also elsewhere on the board
LCD-D22: J300.13; also elsewhere on the board
LCD-D23: J300.12; also elsewhere on the board
LCD-DE: J300.38; also elsewhere on the board
LCD-HSYNC: J300.40; also elsewhere on the board
LCD-VSYNC: J300.41; also elsewhere on the board
LCD_BL: J300.42; also elsewhere on the board
LCD_RESET: J300.9; also elsewhere on the board
LED_BLUE: R8.1; also elsewhere on the board
LED_GREEN: R7.1; also elsewhere on the board
LED_RED: R6.1; also elsewhere on the board
unnamed: D4.1 (BK), R8.2
unnamed: D4.3 (GK), R7.2
unnamed: D4.4 (RK), R6.2
unnamed: R9.2, SW2.2
unnamed: R20.2, SW1.2
PWRON: C38.1, R9.1; also elsewhere on the board
SDC0-CLK: J101.P5 (CLK); also elsewhere on the board
SDC0-CMD: J101.P3 (CMD); also elsewhere on the board
SDC0-D0: J101.P7 (DAT0); also elsewhere on the board
SDC0-D1: J101.P8 (DAT1); also elsewhere on the board
SDC0-D2: J101.P1 (DAT2); also elsewhere on the board
SDC0-D3: J101.P2 (DAT3/CD); also elsewhere on the board
SDC0-DET: J101.CD1 (DET_A), J101.CD2 (DET_B); also elsewhere on the board
SDC2-CMD: J1.26; also elsewhere on the board
SPI-CLK: J1.25; also elsewhere on the board
SPI-MISO: J1.28; also elsewhere on the board
SPI-MOSI: J1.27; also elsewhere on the board
TOUCH-XL: J300.5; also elsewhere on the board
TOUCH-XR: J300.3; also elsewhere on the board
TOUCH-YD: J300.2; also elsewhere on the board
TOUCH-YU: J300.4; also elsewhere on the board
UART1-RXD: J1.12; also elsewhere on the board
UART1-TXD: J1.11; also elsewhere on the board
UART2-RX: J1.22; also elsewhere on the board
UART2-TX: J1.21; also elsewhere on the board
USB0-D+: U1.4 (I/O2); also elsewhere on the board
USB0-D-: U1.6 (I/O1); also elsewhere on the board
USB0_ID: D2.1 (A1), J100.4 (ID), R16.2; also elsewhere on the board
VBAT: J1.4; also elsewhere on the board
~RST: J1.7; also elsewhere on the board

Notices in the files:
hardware/module.kicad_pcb:
© VDRD
