# Repository vd-rd/sbc_allwinner_a13 (continued)

## KiCad design hardware/module.kicad_pcb (continued)

Parts:
C39, C200, C201, C202, C203, C204, C205, C206, C207, C208, C209, C211, C212, C213, C214: 100nF; C_0402_1005Metric
C210: 100uF; CP_EIA-2012-15_AVX-P
R1, R4: 240; R_0402_1005Metric
R2, R3, R10, R11, R12, R13, R14, R15: 24; R_0402_1005Metric
R200, R201: 2.2k; R_0402_1005Metric
RN1, RN2, RN3, RN4, RN5, RN6, RN7, RN8, RN9, RN10: 24; R_Array_Concave_4x0402
TP21: TestPoint; TestPoint_Pad_D1.0mm
U100: A13; LQFP-176_20x20mm_P0.4mm
U200: DDR3L-x16; BGA-96_9x14mm_P0.8mm

Connections:
+1V5: C200.1, C201.1, C202.1, C203.1, C204.1, C205.1, C206.1, C207.1, C208.1, C209.1, C210.1, C213.1, R200.2, U200.A1 (VDDQ), U200.A8 (VDDQ), U200.B2 (VDD), U200.C1 (VDDQ), U200.C9 (VDDQ), U200.D2 (VDDQ), U200.D9 (VDD), U200.E9 (VDDQ), U200.F1 (VDDQ), U200.G7 (VDD), U200.H2 (VDDQ), U200.H9 (VDDQ), U200.K2 (VDD), U200.K8 (VDD), U200.N1 (VDD), U200.N9 (VDD), U200.R1 (VDD), U200.R9 (VDD); also elsewhere on the board
/DDR3 Memory/a00: RN7.5 (R4.2), U100.64 (SA0)
/DDR3 Memory/a01: RN9.7 (R2.2), U100.52 (SA1)
/DDR3 Memory/a02: RN6.7 (R2.2), U100.66 (SA2)
/DDR3 Memory/a03: RN6.8 (R1.2), U100.65 (SA3)
/DDR3 Memory/a04: RN9.8 (R1.2), U100.51 (SA4)
/DDR3 Memory/a05: RN6.6 (R3.2), U100.67 (SA5)
/DDR3 Memory/a06: RN9.6 (R3.2), U100.54 (SA6)
/DDR3 Memory/a07: RN5.6 (R3.2), U100.71 (SA7)
/DDR3 Memory/a08: RN9.5 (R4.2), U100.55 (SA8)
/DDR3 Memory/a09: RN5.8 (R1.2), U100.69 (SA9)
/DDR3 Memory/a10: RN10.7 (R2.2), U100.48 (SA10)
/DDR3 Memory/a11: RN8.8 (R1.2), U100.56 (SA11)
/DDR3 Memory/a12: RN10.5 (R4.2), U100.50 (SA12)
/DDR3 Memory/a13: RN6.5 (R4.2), U100.68 (SA13)
/DDR3 Memory/a14: RN8.7 (R2.2), U100.57 (SA14)
/DDR3 Memory/ba0: RN7.6 (R3.2), U100.63 (BA0)
/DDR3 Memory/ba1: RN10.6 (R3.2), U100.49 (BA1)
/DDR3 Memory/ba2: RN7.7 (R2.2), U100.61 (BA2)
/DDR3 Memory/cas: RN8.5 (R4.2), U100.59 (CAS)
/DDR3 Memory/ck+: R2.2, U100.45 (CK+)
/DDR3 Memory/ck-: R3.2, U100.46 (CK-)
/DDR3 Memory/cke: RN10.8 (R1.2), U100.47 (CKE)
/DDR3 Memory/d00: RN4.5 (R4.2), U100.22 (SDQ0)
/DDR3 Memory/d01: RN1.8 (R1.2), U100.40 (SDQ1)
/DDR3 Memory/d02: RN4.6 (R3.2), U100.21 (SDQ2)
/DDR3 Memory/d03: RN1.7 (R2.2), U100.41 (SDQ3)
/DDR3 Memory/d04: RN4.8 (R1.2), U100.19 (SDQ4)
/DDR3 Memory/d05: RN1.5 (R4.2), U100.44 (SDQ5)
/DDR3 Memory/d06: RN4.7 (R2.2), U100.20 (SDQ6)
/DDR3 Memory/d07: RN1.6 (R3.2), U100.42 (SDQ7)
/DDR3 Memory/d08: RN2.7 (R2.2), U100.37 (SDQ8)
/DDR3 Memory/d09: RN3.7 (R2.2), U100.25 (SDQ9)
/DDR3 Memory/d10: RN2.5 (R4.2), U100.39 (SDQ10)
/DDR3 Memory/d11: RN3.8 (R1.2), U100.24 (SDQ11)
/DDR3 Memory/d12: RN2.8 (R1.2), U100.36 (SDQ12)
/DDR3 Memory/d13: RN3.6 (R3.2), U100.26 (SDQ13)
/DDR3 Memory/d14: RN2.6 (R3.2), U100.38 (SDQ14)
/DDR3 Memory/d15: RN3.5 (R4.2), U100.27 (SDQ15)
/DDR3 Memory/ddr-a0: RN7.4 (R4.1), U200.N3 (A0)
/DDR3 Memory/ddr-a1: RN9.2 (R2.1), U200.P7 (A1)
/DDR3 Memory/ddr-a2: RN6.2 (R2.1), U200.P3 (A2)
/DDR3 Memory/ddr-a3: RN6.1 (R1.1), U200.N2 (A3)
/DDR3 Memory/ddr-a4: RN9.1 (R1.1), U200.P8 (A4)
/DDR3 Memory/ddr-a5: RN6.3 (R3.1), U200.P2 (A5)
/DDR3 Memory/ddr-a6: RN9.3 (R3.1), U200.R8 (A6)
/DDR3 Memory/ddr-a7: RN5.3 (R3.1), U200.R2 (A7)
/DDR3 Memory/ddr-a8: RN9.4 (R4.1), U200.T8 (A8)
/DDR3 Memory/ddr-a9: RN5.1 (R1.1), U200.R3 (A9)
/DDR3 Memory/ddr-a10: RN10.2 (R2.1), U200.L7 (A10/AP)
/DDR3 Memory/ddr-a11: RN8.1 (R1.1), U200.R7 (A11)
/DDR3 Memory/ddr-a12: RN10.4 (R4.1), U200.N7 (A12/~BC)
/DDR3 Memory/ddr-a13: RN6.4 (R4.1), U200.T3 (A13)
/DDR3 Memory/ddr-a14: RN8.2 (R2.1), U200.T7 (A14)
/DDR3 Memory/ddr-a15: U200.M7 (A15(nc))
/DDR3 Memory/ddr-ba0: RN7.3 (R3.1), U200.M2 (BA0)
/DDR3 Memory/ddr-ba1: RN10.3 (R3.1), U200.N8 (BA1)
/DDR3 Memory/ddr-ba2: RN7.2 (R2.1), U200.M3 (BA2)
/DDR3 Memory/ddr-cas: RN8.4 (R4.1), U200.K3 (~CAS)
/DDR3 Memory/ddr-ck+: R2.1, U200.J7 (CK)
/DDR3 Memory/ddr-ck-: R3.1, U200.K7 (~CK)
/DDR3 Memory/ddr-cke: RN10.1 (R1.1), U200.K9 (CKE)
/DDR3 Memory/ddr-d0: RN4.4 (R4.1), U200.E3 (DQL0)
/DDR3 Memory/ddr-d1: RN1.1 (R1.1), U200.F7 (DQL1)
/DDR3 Memory/ddr-d2: RN4.3 (R3.1), U200.F2 (DQL2)
/DDR3 Memory/ddr-d3: RN1.2 (R2.1), U200.F8 (DQL3)
/DDR3 Memory/ddr-d4: RN4.1 (R1.1), U200.H3 (DQL4)
/DDR3 Memory/ddr-d5: RN1.4 (R4.1), U200.H8 (DQL5)
/DDR3 Memory/ddr-d6: RN4.2 (R2.1), U200.G2 (DQL6)
/DDR3 Memory/ddr-d7: RN1.3 (R3.1), U200.H7 (DQL7)
/DDR3 Memory/ddr-d8: RN2.2 (R2.1), U200.D7 (DQU0)
/DDR3 Memory/ddr-d9: RN3.2 (R2.1), U200.C3 (DQU1)
/DDR3 Memory/ddr-d10: RN2.4 (R4.1), U200.C8 (DQU2)
/DDR3 Memory/ddr-d11: RN3.1 (R1.1), U200.C2 (DQU3)
/DDR3 Memory/ddr-d12: RN2.1 (R1.1), U200.A7 (DQU4)
/DDR3 Memory/ddr-d13: RN3.3 (R3.1), U200.A2 (DQU5)
/DDR3 Memory/ddr-d14: RN2.3 (R3.1), U200.B8 (DQU6)
/DDR3 Memory/ddr-d15: RN3.4 (R4.1), U200.A3 (DQU7)
/DDR3 Memory/ddr-dm0: R14.1, U200.E7 (DML)
/DDR3 Memory/ddr-dm1: R15.1, U200.D3 (DMU)
/DDR3 Memory/ddr-dqs0+: R10.1, U200.F3 (DQSL)
/DDR3 Memory/ddr-dqs0-: R11.1, U200.G3 (~DQSL)
/DDR3 Memory/ddr-dqs1+: R12.1, U200.C7 (DQSU)
/DDR3 Memory/ddr-dqs1-: R13.1, U200.B7 (~DQSU)
/DDR3 Memory/ddr-odt: RN5.4 (R4.1), U200.K1 (ODT)
/DDR3 Memory/ddr-ras: RN8.3 (R3.1), U200.J3 (~RAS)
/DDR3 Memory/ddr-rst: RN5.2 (R2.1), U200.T2 (~RESET)
/DDR3 Memory/ddr-we: RN7.1 (R1.1), U200.L3 (~WE)
/DDR3 Memory/dm0: R14.2, U100.29 (DM0)
/DDR3 Memory/dm1: R15.2, U100.28 (DM1)
/DDR3 Memory/dqs0+: R10.2, U100.31 (DQS0+)
/DDR3 Memory/dqs0-: R11.2, U100.32 (DQS0-)
/DDR3 Memory/dqs1+: R12.2, U100.33 (DQS1+)
/DDR3 Memory/dqs1-: R13.2, U100.34 (DQS1-)
/DDR3 Memory/odt: RN5.5 (R4.2), U100.72 (ODT)
/DDR3 Memory/ras: RN8.6 (R3.2), U100.58 (RAS)
/DDR3 Memory/rst: RN5.7 (R2.2), U100.70 (RST)
/DDR3 Memory/svref: C39.1, C211.1, C212.1, C213.2, C214.1, R200.1, R201.2, TP21.1 (1_1), U100.18 (SVREF), U200.H1 (VREFDQ), U200.M8 (VREFCA)
/DDR3 Memory/we: RN7.8 (R1.2), U100.60 (WE)
/DDR3 Memory/zq: R1.2, U100.17 (DZQ)
GND: C39.2, C200.2, C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C214.2, R1.1, R4.1, R201.1, U200.A9 (VSS), U200.B1 (VSSQ), U200.B3 (VSS), U200.B9 (VSSQ), U200.D1 (VSSQ), U200.D8 (VSSQ), U200.E1 (VSS), U200.E2 (VSSQ), U200.E8 (VSSQ), U200.F9 (VSSQ), U200.G1 (VSSQ), U200.G8 (VSS), U200.G9 (VSSQ), U200.J2 (VSS), U200.J8 (VSS), U200.L2 (~CS), U200.M1 (VSS), U200.M9 (VSS), U200.P1 (VSS), U200.P9 (VSS), U200.T1 (VSS), U200.T9 (VSS); also elsewhere on the board
unnamed: R4.2, U200.L8 (ZQ)

Board: 4 copper layers, 80.0 x 42.0 mm, 177 parts (8 on the bottom side), 222 nets.

## KiCad design ram-detail/ram-detail.kicad_pcb

Parts:
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_2.7mm_M2.5_DIN965

Parts:
C1, C4, C6, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34: 100nF; C_0402_1005Metric
C2, C9: 10uF; C_0603_1608Metric
C3, C7: 22pF; C_0402_1005Metric
C5: 4.7uF; C_0603_1608Metric
C8: 1uF; C_0402_1005Metric
R5: 200k; R_0402_1005Metric
U100: A13; LQFP-176_20x20mm_P0.4mm
Y1: 24MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V2_CPU: C12.1, C13.1, C17.1, C21.1, C25.1, C29.1, C33.1, C34.1, U100.4 (VDD_CPU), U100.9 (VDD_CPU), U100.11 (VDD_CPU), U100.16 (VDD_CPU), U100.156 (VDD_CPU), U100.164 (VDD_CPU), U100.169 (VDD_CPU), U100.173 (VDD_CPU)
+1V2_INT: C16.1, C20.1, C24.1, C28.1, C32.1, U100.35 (VDD_INT), U100.73 (VDD_INT), U100.98 (VDD_INT), U100.109 (VDD_INT), U100.149 (VDD_INT)
+1V5: C15.1, C19.1, C23.1, C27.1, C31.1, U100.23 (VCC_DRAM), U100.30 (VCC_DRAM), U100.43 (VCC_DRAM), U100.53 (VCC_DRAM), U100.62 (VCC_DRAM); also elsewhere on the board
+3V0: C1.1, U100.81 (AVCC)
+3V3: C14.1, C18.1, C22.1, C26.1, C30.1, U100.5 (IOVCC), U100.97 (UVCC), U100.100 (IOVCC), U100.142 (IOVCC), U100.163 (IOVCC); also elsewhere on the board
/cpu/hp_bp: C2.1, C4.1, U100.75 (HPBP)
/cpu/hp_vcc: C10.1, U100.76 (V33_HP)
/cpu/hpcom: U100.77 (HPCOM)
/cpu/hpoutl: U100.74 (HPOUTL)
/cpu/hpoutr: U100.78 (HPOUTR)
/cpu/hse_in: C7.1, U100.92 (X24MIN), Y1.3
/cpu/hse_out: C3.1, U100.91 (X24MOUT), Y1.1
/cpu/micin: U100.84 (MICIN1)
/cpu/vmic: U100.85 (VMIC)
/cpu/vra1: C8.1, U100.83 (VRA1)
/cpu/vra2: C5.1, C6.1, R5.1, U100.82 (VRA2)
/cpu/vrp: C9.1, C11.1, U100.80 (VRP)
BUTTON: U100.86 (LRADC); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, R5.2, U100.79 (AGND), U100.177 (GND), Y1.2, Y1.4; also elsewhere on the board
NMI: U100.158 (NMI_N)
TOUCH-XL: U100.87 (TPX2); also elsewhere on the board
TOUCH-XR: U100.89 (TPX1); also elsewhere on the board
TOUCH-YD: U100.88 (TPY2); also elsewhere on the board
TOUCH-YU: U100.90 (TPY1); also elsewhere on the board
USB0-D+: U100.94 (UDP0); also elsewhere on the board
USB0-D-: U100.93 (UDM0); also elsewhere on the board
USB1-DM: U100.95 (UDM1)
USB1-DP: U100.96 (UDP1)
~RST: U100.159 (RESET_N); also elsewhere on the board

Parts:
C35, C37, C38: 100nF; C_0402_1005Metric
C36: 1uF; C_0402_1005Metric
D1: LED_RGBA; rgb-1204
J1: Micro_SD_Card_Det; MEM20610118800A
J2: Conn_2Rows-45Pins_Shielded; Hirose_FH12-45S-0.5SH_1x45-1MP_P0.50mm_Horizontal
J3: Conn_02x18_Odd_Even; PinHeader_2x18_P2.54mm_Vertical
J4: USB_B_Micro; USB_Micro-B_Amphenol_10103594-0001LF_Horizontal
R6, R7, R8: 180; R_0402_1005Metric
R9: 1k; R_0402_1005Metric
SW1, SW2: SW_Push; SW_SPST_EVQP7C
U1: USBLC6-2P6; SOT-666

Connections:
+3V3: C35.1, C36.1, D1.4 (A), J1.P4 (VDD), J3.2; also elsewhere on the board
+5V_USB: C37.1, J4.1 (VBUS), U1.5 (VBUS)
/io/usb-d+: J4.3 (D+), U1.3 (I/O2)
/io/usb-d-: J4.2 (D-), U1.1 (I/O1)
ACIN: J3.3
BAT_GND: J3.5
BAT_NTC: J3.6
BUTTON: SW1.1; also elsewhere on the board
CAN-RX: J3.30
CAN-TX: J3.29
GND: C35.2, C36.2, C37.2, C38.2, J1.G1 (SHIELD), J1.G2 (SHIELD), J1.P6 (VSS), J2.5, J2.6, J2.20, J2.21, J2.28, J2.29, J2.36, J2.37, J2.MP (MountPin), J3.1, J3.14, J3.23, J3.36, J4.5 (GND), J4.6 (Shield), SW2.1, U1.2 (GND); also elsewhere on the board
GPIO1: J3.13
GPIO2: J3.20
GPIO3: J3.19
GPIO4: J3.24
GPIOA1: J3.31
GPIOA2: J3.32
GPIOA3: J3.33
GPIOA4: J3.34
GPIOA5: J3.35
I2C-SCL: J3.17
I2C-SDA: J3.18
LCD-CLK: J2.39
LCD-D2: J2.35
LCD-D3: J2.34
LCD-D4: J2.33
LCD-D5: J2.32
LCD-D6: J2.31
LCD-D7: J2.30
LCD-D10: J2.27
LCD-D11: J2.26
LCD-D12: J2.25
LCD-D13: J2.24
LCD-D14: J2.23
LCD-D15: J2.22
LCD-D18: J2.19
LCD-D19: J2.18
LCD-D20: J2.17
LCD-D21: J2.16
LCD-D22: J2.15
LCD-D23: J2.14
LCD-DE: J2.38
LCD-HSYNC: J2.40
LCD-VSYNC: J2.41
LED_A: J2.44
LED_BLUE: R8.1
LED_GREEN: R7.1
LED_K: J2.43
LED_RED: R6.1
unnamed: C38.1, R9.2, SW2.2
unnamed: D1.3 (BK), R8.2
unnamed: D1.2 (GK), R7.2
unnamed: D1.1 (RK), R6.2
PWRON: R9.1
SDC0-CLK: J1.P5 (CLK)
SDC0-CMD: J1.P3 (CMD)
SDC0-D0: J1.P7 (DAT0)
SDC0-D1: J1.P8 (DAT1)
SDC0-D2: J1.P1 (DAT2)
SDC0-D3: J1.P2 (DAT3/CD)
SDC0-DET: J1.CD1 (DET_A), J1.CD2 (DET_B)
SPI-CLK: J3.25
SPI-CS: J3.26
SPI-MISO: J3.28
SPI-MOSI: J3.27
TOUCH-XL: J2.3; also elsewhere on the board
TOUCH-XR: J2.1; also elsewhere on the board
TOUCH-YD: J2.2; also elsewhere on the board
TOUCH-YU: J2.4; also elsewhere on the board
UART1-RXD: J3.12
UART1-TXD: J3.11
UART2-RX: J3.22
UART2-TX: J3.21
USB0-D+: U1.4 (I/O2); also elsewhere on the board
USB0-D-: U1.6 (I/O1); also elsewhere on the board
VBAT: J3.4
~RST: J3.7; also elsewhere on the board

Parts:
R1, R4: 240; R_0402_1005Metric
R2, R3: 22; R_0402_1005Metric
U100: A13; LQFP-176_20x20mm_P0.4mm
U200: DDR3L-x16; BGA-96_9x14mm_P0.8mm

Connections:
+1V5: U200.A1 (VDDQ), U200.A8 (VDDQ), U200.B2 (VDD), U200.C1 (VDDQ), U200.C9 (VDDQ), U200.D2 (VDDQ), U200.D9 (VDD), U200.E9 (VDDQ), U200.F1 (VDDQ), U200.G7 (VDD), U200.H2 (VDDQ), U200.H9 (VDDQ), U200.K2 (VDD), U200.K8 (VDD), U200.N1 (VDD), U200.N9 (VDD), U200.R1 (VDD), U200.R9 (VDD); also elsewhere on the board
/sdram/ddr-a0: U100.64 (SA0), U200.N3 (A0)
/sdram/ddr-a1: U100.52 (SA1), U200.P7 (A1)
/sdram/ddr-a2: U100.66 (SA2), U200.P3 (A2)
/sdram/ddr-a3: U100.65 (SA3), U200.N2 (A3)
/sdram/ddr-a4: U100.51 (SA4), U200.P8 (A4)
/sdram/ddr-a5: U100.67 (SA5), U200.P2 (A5)
/sdram/ddr-a6: U100.54 (SA6), U200.R8 (A6)
/sdram/ddr-a7: U100.71 (SA7), U200.R2 (A7)
/sdram/ddr-a8: U100.55 (SA8), U200.T8 (A8)
/sdram/ddr-a9: U100.69 (SA9), U200.R3 (A9)
/sdram/ddr-a10: U100.48 (SA10), U200.L7 (A10/AP)
/sdram/ddr-a11: U100.56 (SA11), U200.R7 (A11)
/sdram/ddr-a12: U100.50 (SA12), U200.N7 (A12/~BC)
/sdram/ddr-a13: U100.68 (SA13), U200.T3 (A13)
/sdram/ddr-a14: U100.57 (SA14), U200.T7 (A14)
/sdram/ddr-a15: U200.M7 (A15(nc))
/sdram/ddr-ba0: U100.63 (BA0), U200.M2 (BA0)
/sdram/ddr-ba1: U100.49 (BA1), U200.N8 (BA1)
/sdram/ddr-ba2: U100.61 (BA2), U200.M3 (BA2)
/sdram/ddr-cas: U100.59 (CAS), U200.K3 (~CAS)
/sdram/ddr-ck+: R2.1, U200.J7 (CK)
/sdram/ddr-ck-: R3.1, U200.K7 (~CK)
/sdram/ddr-cke: U100.47 (CKE), U200.K9 (CKE)
/sdram/ddr-d0: U100.22 (SDQ0), U200.E3 (DQL0)
/sdram/ddr-d1: U100.40 (SDQ1), U200.F7 (DQL1)
/sdram/ddr-d2: U100.21 (SDQ2), U200.F2 (DQL2)
/sdram/ddr-d3: U100.41 (SDQ3), U200.F8 (DQL3)
/sdram/ddr-d4: U100.19 (SDQ4), U200.H3 (DQL4)
/sdram/ddr-d5: U100.44 (SDQ5), U200.H8 (DQL5)
/sdram/ddr-d6: U100.20 (SDQ6), U200.G2 (DQL6)
/sdram/ddr-d7: U100.42 (SDQ7), U200.H7 (DQL7)
/sdram/ddr-d8: U100.37 (SDQ8), U200.D7 (DQU0)
/sdram/ddr-d9: U100.25 (SDQ9), U200.C3 (DQU1)
/sdram/ddr-d10: U100.39 (SDQ10), U200.C8 (DQU2)
/sdram/ddr-d11: U100.24 (SDQ11), U200.C2 (DQU3)
/sdram/ddr-d12: U100.36 (SDQ12), U200.A7 (DQU4)
/sdram/ddr-d13: U100.26 (SDQ13), U200.A2 (DQU5)
/sdram/ddr-d14: U100.38 (SDQ14), U200.B8 (DQU6)
/sdram/ddr-d15: U100.27 (SDQ15), U200.A3 (DQU7)
/sdram/ddr-dm0: U100.29 (DM0), U200.E7 (DML)
/sdram/ddr-dm1: U100.28 (DM1), U200.D3 (DMU)
/sdram/ddr-dqs0+: U100.31 (DQS0+), U200.F3 (DQSL)
/sdram/ddr-dqs0-: U100.32 (DQS0-), U200.G3 (~DQSL)
/sdram/ddr-dqs1+: U100.33 (DQS1+), U200.C7 (DQSU)
/sdram/ddr-dqs1-: U100.34 (DQS1-), U200.B7 (~DQSU)
/sdram/ddr-odt: U100.72 (ODT), U200.K1 (ODT)
/sdram/ddr-ras: U100.58 (RAS), U200.J3 (~RAS)
/sdram/ddr-rst: U100.70 (RST), U200.T2 (~RESET)
/sdram/ddr-we: U100.60 (WE), U200.L3 (~WE)
/sdram/svref: U100.18 (SVREF), U200.H1 (VREFDQ), U200.M8 (VREFCA)
GND: R1.1, R4.1, U200.A9 (VSS), U200.B1 (VSSQ), U200.B3 (VSS), U200.B9 (VSSQ), U200.D1 (VSSQ), U200.D8 (VSSQ), U200.E1 (VSS), U200.E2 (VSSQ), U200.E8 (VSSQ), U200.F9 (VSSQ), U200.G1 (VSSQ), U200.G8 (VSS), U200.G9 (VSSQ), U200.J2 (VSS), U200.J8 (VSS), U200.L2 (~CS), U200.M1 (VSS), U200.M9 (VSS), U200.P1 (VSS), U200.P9 (VSS), U200.T1 (VSS), U200.T9 (VSS); also elsewhere on the board
unnamed: R2.2, U100.45 (CK+)
unnamed: R3.2, U100.46 (CK-)
unnamed: R1.2, U100.17 (DZQ)
unnamed: R4.2, U200.L8 (ZQ)

Board: 2 copper layers, 64 parts (1 on the bottom side), 82 nets, no tracks yet.

## Commit log (part)

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2019-04-30 board: define board shape and connectors
2019-04-30 board: add processor and ram
2019-04-30 board: add ddr3 termination resistors
2019-04-30 schematic: defined ddr3 connections
2019-04-30 schematic: added more sdram nets
2019-04-30 schematic: defined functions for peripherals
2019-04-30 board: add power components
2019-05-01 board: added esd protection
2019-05-02 board: added wifi/bt combo module
2021-09-22 project cleanup
2021-09-22 switch to kicad
2021-09-22 updated layout
2021-09-24 improve floorplan
2021-09-27 defined floorplan for board
2021-10-16 added pmic
2021-10-17 new layout for dram chip
2021-10-19 optimize dram placement
2021-10-19 swapped wifi module
2021-10-23 added lcd connector and bl driver
2021-10-25 added 3d models
2021-11-15 defined floorplan
2021-11-25 more dram routing
2021-12-05 small changes to ram layout
2021-12-12 more ddr routing
2021-12-13 pmic optimizations
2021-12-17 pmic routing
2021-12-24 more signal routing
2021-12-27 testing new layout
2021-12-27 reposition components on tryout board
2021-12-30 reaching rc0.1
2021-12-31 add dcdc for 1.2v int rail
2022-01-02 added audio breakout
2022-01-02 add board preview
2022-01-03 small changes
2022-01-11 routed sdio0 bus
2022-01-14 added missing values for components
2022-01-16 add layer identification labels
2022-01-17 preparing for release
2022-01-18 added all lcd connector signals
2022-01-18 power rails completed
2022-01-18 board fully routed
2022-01-19 exported gerbers
2022-01-29 added testpoints for RSB
2022-01-29 prepare for v1.1.0
2022-01-30 add new lcd connector
2022-02-02 route new lcd connector
2022-02-02 swapped rtc for mcp794x
2022-02-11 small rtc fixes
2022-02-16 add global fiducials
2022-02-16 add silkscreen info for big footprints
2022-02-21 small fixes
2022-02-21 add a testpoint
2022-02-22 swap inductors for smaller footprints
2022-03-01 fix pull-up values
2022-03-09 fix testpoint position
2022-03-24 add ldo3 cap
2022-03-24 new board features
    axp209 adc pins
    chg led
2022-03-24 finish aux pmics
2022-03-28 prepare new board revision
2022-03-30 prep for fab
2022-04-05 added new uart port
2022-04-07 relax spacing between signals
2022-04-30 add board info
2022-06-30 swap rtc for onboard spi
2022-07-01 update board preview
2022-07-07 fix audio connector
2022-07-10 clean board silkscreen
2022-07-10 add alternative parts
2023-12-25 chore: update to kicad7 format
2024-03-31 bump to kicad v8
2024-08-16 latest fixes for fab
2024-08-16 updated silk and description
2024-10-28 [WIP] Rework power tree
2025-01-10 rework component placement
2025-01-10 Add MkDocs Material pages
2025-01-10 Add basic mkdocs config
2025-01-10 organize project structure
2025-01-10 add first docs
2025-01-10 fix typo
2025-01-10 enable plugins
2025-07-19 wip rework
2026-01-04 prepare for rev2
2026-01-04 small cosmetic fixes
2026-01-05 axp209 layout optimisations
2026-01-26 updated cpu connections
2026-02-03 more routing
2026-04-26 Refactor code structure for improved readability and maintainability
2026-04-29 more routing for v2
2026-04-29 finished routing rev2
2026-05-03 finished routing v2
2026-05-27 update board renders for rev2
2026-06-09 drc and cosmetics for rev2
2026-06-29 test release workflow
2026-06-29 test release workflow (#10)
